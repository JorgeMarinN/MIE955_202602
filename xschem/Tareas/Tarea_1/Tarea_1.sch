v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 -4280 -810 -4280 -620 {}
L 4 -4280 -620 -4280 -600 {}
L 4 -3990 -810 -3990 -620 {}
L 4 -3990 -620 -3990 -600 {}
L 4 -3630 -810 -3630 -620 {}
L 4 -3630 -620 -3630 -600 {}
L 4 -4280 -810 -3630 -810 {}
L 4 -4280 -740 -3630 -740 {}
L 4 -4280 -600 -3630 -600 {}
T {Actividad 1.} -4230 -800 0 0 0.6 0.6 {}
T {Actividad 2.} -3900 -800 0 0 0.6 0.6 {}
C {title.sym} -4150 -530 0 0 {name=l1 author="Prof: Jorge Marín"}
C {../Tarea_1/nmoslv_charac_MIE955-202602-HW1.sym} -4120 -590 0 0 {name=X1}
C {../Tarea_1/cs_amp_full_MIE955HW1.sym} -3830 -590 0 0 {name=X2}
